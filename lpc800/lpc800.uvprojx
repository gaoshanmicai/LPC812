# Keil uVision project lpc800.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC811M001JDH16 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IROM(0x00000000,0x00002000) IRAM(0x10000000,0x00000800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lpc800
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x800
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 4.1.0, Board Support:LED 1.0.0, Device:Startup 1.0.1
